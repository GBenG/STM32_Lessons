# Keil uVision project SPS_LED.uvproj, settings and files
target SPS_LED (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SPS_LED +hex
  c flags: Optim=1
  c define: STM32F10X_MD_VL
  c include: .\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;.\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\SPS_test
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUP
    ./: startup_stm32f10x_md_vl.s
  group MainCore
    ./: main.c
  group CMSIS
    ./: core_cm3.c system_stm32f10x.c
